# IAR project eth2i3c.ewp, settings and files
configuration eth2i3c (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H563xx; STM32H5
  ICCARM.CCDiagSuppress: Pa045,Pe191
  ICCARM.CCIncludePath2: ../Inc; ../../common/Drivers/STM32H5xx_HAL_Driver/Inc; ../../common/Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../common/Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../common/Drivers/CMSIS/Include; ../../common/Drivers/CMSIS/RTOS2/Include; ../../common/CMSIS-FreeRTOS/Source/include; ../../common/CMSIS-FreeRTOS/CMSIS/RTOS2/FreeRTOS/Include; ../../common/FreeRTOS-Plus-TCP/source/include; ../../common/FreeRTOS-Plus-TCP/source/portable/Compiler/IAR; ../../common/FreeRTOS-Plus-TCP/source/portable/NetworkInterface/include; ../../common/CMSIS-FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32H563xx; STM32H5
  AARM.AUserIncludes: ../Inc; ../../common/CMSIS-FreeRTOS/Source/include; ../../common/CMSIS-FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure
  OBJCOPY.OOCOutputFile: eth2i3c.hex
  ILINK.IlinkOutputFile: eth2i3c.out
  ILINK.IlinkIcfFile: stm32h563xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Src/: app_freertos.c cmd.c i3c_bus.c i3c_target.c main.c stm32h5xx_hal_msp.c stm32h5xx_hal_timebase_tim.c stm32h5xx_it.c system_stm32h5xx.c tcp_server.c
  group Drivers
    ../../common/Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_i3c.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group FreeRTOS
    ../../common/CMSIS-FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../common/CMSIS-FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../common/CMSIS-FreeRTOS/CMSIS/RTOS2/FreeRTOS/Source/: cmsis_os2.c
    ../../common/CMSIS-FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group FreeRTOS-Plus-TCP
    ../../common/FreeRTOS-Plus-TCP/source/: FreeRTOS_ARP.c FreeRTOS_BitConfig.c FreeRTOS_DHCP.c FreeRTOS_DHCPv6.c FreeRTOS_DNS.c FreeRTOS_DNS_Cache.c FreeRTOS_DNS_Callback.c FreeRTOS_DNS_Networking.c FreeRTOS_DNS_Parser.c FreeRTOS_ICMP.c FreeRTOS_IP.c FreeRTOS_IP_Timers.c FreeRTOS_IP_Utils.c FreeRTOS_IPv4.c FreeRTOS_IPv4_Sockets.c FreeRTOS_IPv4_Utils.c FreeRTOS_IPv6.c FreeRTOS_IPv6_Sockets.c FreeRTOS_IPv6_Utils.c FreeRTOS_ND.c FreeRTOS_RA.c FreeRTOS_Routing.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_IP_IPv4.c FreeRTOS_TCP_IP_IPv6.c FreeRTOS_TCP_Reception.c FreeRTOS_TCP_State_Handling.c FreeRTOS_TCP_State_Handling_IPv4.c FreeRTOS_TCP_State_Handling_IPv6.c FreeRTOS_TCP_Transmission.c FreeRTOS_TCP_Transmission_IPv4.c FreeRTOS_TCP_Transmission_IPv6.c FreeRTOS_TCP_Utils.c FreeRTOS_TCP_Utils_IPv4.c FreeRTOS_TCP_Utils_IPv6.c FreeRTOS_TCP_WIN.c FreeRTOS_Tiny_TCP.c FreeRTOS_UDP_IP.c FreeRTOS_UDP_IPv4.c FreeRTOS_UDP_IPv6.c
    ../../common/FreeRTOS-Plus-TCP/source/portable/BufferManagement/: BufferAllocation_1.c
    ../../common/FreeRTOS-Plus-TCP/source/portable/NetworkInterface/Common/: phyHandling.c
    ../../common/FreeRTOS-Plus-TCP/source/portable/NetworkInterface/STM32/: NetworkInterface.c
    ../../common/FreeRTOS-Plus-TCP/source/portable/NetworkInterface/STM32/Drivers/H5/: stm32h5xx_hal_eth.c stm32h5xx_hal_eth_ex.c
  group Startup
    ./: startup_stm32h563xx.s
  group Doc
    ../: README.md README-CN.md
